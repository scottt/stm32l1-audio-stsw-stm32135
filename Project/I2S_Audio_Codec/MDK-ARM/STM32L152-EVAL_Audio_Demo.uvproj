# Keil uVision project STM32L152-EVAL_Audio_Demo.uvproj, settings and files
target STM32L152D-EVAL_Audio_Demo (ARM-ADS)
  device: STM32L152ZD STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x805FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32L152D-EVAL.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32L1XX_HD,USE_STM32L152D_EVAL,USB_USE_EXTERNAL_PULLUP,USE_TIMEOUT_USER_CALLBACK
  c include: ..\inc;..\..\..\..\..\Libraries\CMSIS\Device\ST\STM32L1xx\Include;..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM32L152D_EVAL;..\..\..\Utilities\Third_Party\FatFs_vR0.08a
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ../src/: stm32l1xx_it.c main.c menu.c waveplayer.c storage.c iddmeasurement.c stm32l1xx_clock_config.c diskio.c
  group StdPeriph_Driver
    ../../../Libraries/stm32l1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_lcd.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c
    ../../../Libraries/STM32L1xx_StdPeriph_Driver/src/: stm32l1xx_sdio.c stm32l1xx_fsmc.c stm32l1xx_opamp.c
  group MDK-ARM
    ./: startup_stm32l1xx_hd.s
  group CMSIS
    ../src/: system_stm32l1xx.c
  group STM32L152D-EVAL
    ../../../Utilities/STM32_EVAL/STM32L152D_EVAL/: stm32l152d_eval.c stm32l152d_eval_audio_codec.c stm32l152d_eval_i2c_ee.c stm32l152d_eval_lcd.c stm32l152d_eval_sdio_sd.c
  group FatFs
    ../../../Utilities/Third_Party/FatFs_vR0.08a/: ff.c
  group Doc
    ../: readme.txt
