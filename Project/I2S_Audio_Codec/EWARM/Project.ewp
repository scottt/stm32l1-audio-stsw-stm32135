# IAR project Project.ewp, settings and files
configuration STM32L152D-EVAL_Audio_Demo (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152xD ST STM32L152xD
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32L1XX_HD; USE_STM32L152D_EVAL; USB_USE_EXTERNAL_PULLUP; USE_TIMEOUT_USER_CALLBACK
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\Libraries\CMSIS\Device\ST\STM32L1xx\Include; ..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\inc; ..\..\..\Libraries\STM32_USB-FS-Device_Driver\inc; ..\..\..\Utilities\STM32_EVAL; ..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\Utilities\STM32_EVAL\STM32L152D_EVAL; ..\..\..\Utilities\Third_Party\FatFs_vR0.08a
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: STM32L152D-EVAL_Audio_Demo.out
  ILINK.IlinkIcfFile: STM32L152xD_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../src/: system_stm32l1xx.c
  group Doc
    ../: readme.txt
  group EWARM
    ../../../Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/iar/: startup_stm32l1xx_hd.s
  group FatFs
    ../../../Utilities/Third_Party/FatFs_vR0.08a/: ff.c
  group StdPeriph_Driver
    ../../../Libraries/stm32l1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_lcd.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c
    ../../../Libraries/STM32L1xx_StdPeriph_Driver/src/: stm32l1xx_fsmc.c stm32l1xx_opamp.c stm32l1xx_sdio.c
  group STM32L152D-EVAL
    ../../../Utilities/STM32_EVAL/STM32L152D_EVAL/: stm32l152d_eval.c stm32l152d_eval_audio_codec.c stm32l152d_eval_i2c_ee.c stm32l152d_eval_lcd.c stm32l152d_eval_sdio_sd.c
  group User
    ../src/: diskio.c iddmeasurement.c main.c menu.c stm32l1xx_clock_config.c stm32l1xx_it.c storage.c waveplayer.c
